# Keil uVision project template.uvprojx, settings and files
target Target 1 (5060061::V5.06 update 1 (build 61)::ARMCC)
  device: STM32F373CC STMicroelectronics
  pack: Keil.STM32F3xx_DFP.1.3.0
  cpu: IROM(0x08000000,0x00040000) IRAM(0x20000000,0x00008000) CPUTYPE("Cortex-M4") FPU2 CLOCK(12000000) ELITTLE
  output: template +hex
  c flags: Optim=1 v6Lang=1 v6LangP=1
  c define: USE_STDPERIPH_DRIVER, STM32F37X,__FPU_PRESENT=1,ARM_MATH_CM4,__CC_ARM,
  c include: ..\Core\Include;..\STM32F37X_StdPeriph_Driver\inc;..\User;..\Hardware;..\DSP_Lib;..\System;..\ProcessingData;d:\keil_V5\ARM\ARMCC\include
  library: MicroLIB
  memory RVCT4: ROM 0x8000000 size 0x40000
  memory RVCT9: RAM 0x20000000 size 0x8000
  group User
    ./: main.c userVAinteraction.c stm32f37x_it.c system_stm32f37x.c comm.c CalA.c
  group Core
    ../Core/Source/: startup_stm32f37x.s
  group STM32F37X_StdPeriph_Driver
    ../STM32F37X_StdPeriph_Driver/src/: stm32f37x_comp.c stm32f37x_dac.c stm32f37x_dma.c stm32f37x_exti.c stm32f37x_gpio.c stm32f37x_misc.c stm32f37x_pwr.c stm32f37x_rtc.c stm32f37x_sdadc.c stm32f37x_syscfg.c stm32f37x_tim.c stm32f37x_usart.c stm32f37x_rcc.c stm32f37x_iwdg.c stm32f37x_flash.c
  group DSP_Lib
    ../DSP_Lib/: arm_cortexM4lf_math.lib
  group System
    ../System/: nvic_systick.c stm32f37x_lp_modes.c
  group ProcessingData
    ../ProcessingData/: stmdataprocess326.c flash_data.c flash_data.h
  group Hardware
    ../Hardware/: matrixkey.c ht1621.c dta0660.c buzzer_led.c comp.c sdadc.c uart.c timer.c dac.c powercontrol.c
  group Doc
    ../Doc/: readme.txt
software components: CMSIS:CORE 4.3.0
